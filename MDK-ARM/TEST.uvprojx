# Keil uVision project TEST.uvprojx, settings and files
target TEST (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: TEST +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../App/main;../BSP/can;../BSP/delay;../BSP/timer;../BSP/usart;../Hardware/biss_coder;../Middleware/Protocol/CANopen;../BSP/rs485;../Middleware/RingBuffer;../BSP/dma;../Middleware/Protocol/Modbus;../Hardware/vfd_driver;../Hardware/tpc_slave;../Hardware/spindle_coder;../Hardware/pinch_driver;../Hardware/scissor_driver;../BSP/flash;../Hardware/selvage_driver
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c can.c dma.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_can.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group APP
    ../App/main/: app_main.c
  group BSP
    ../BSP/can/: bsp_can.c
    ../BSP/delay/: bsp_delay.c
    ../BSP/timer/: bsp_timer.c
    ../BSP/usart/: bsp_usart.c
    ../BSP/rs485/: bsp_rs485.c
    ../BSP/flash/: bsp_flash.c
  group Hardware
    ../Hardware/vfd_driver/: vfd_driver.c
    ../Hardware/tpc_slave/: tpc_slave.c
    ../Hardware/biss_coder/: biss_coder.c
    ../Hardware/spindle_coder/: spindle_coder.c
    ../Hardware/pinch_driver/: pinch_driver.c
    ../Hardware/scissor_driver/: scissor_driver.c
    ../Hardware/selvage_driver/: selvage_driver.c
  group Middleware
    ../Middleware/RingBuffer/: ring_buffer.c
    ../Middleware/Protocol/Modbus/: modbus_rtu.c
    ../Middleware/Protocol/CANopen/: canopen.c
software components: CMSIS:CORE 4.3.0
